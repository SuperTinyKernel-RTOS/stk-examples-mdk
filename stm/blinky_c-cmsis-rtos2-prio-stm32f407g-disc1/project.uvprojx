# Keil uVision project project.uvprojx, settings and files
target device (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: device-stm32f407g-disc1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Example
    ./src/: stk_config.h retarget.c
    ./src/build/example/blinky_c-cmsis-rtos2-prio/: example.c RTE_Components.h
  group STK
    ./deps/stk/src/arch/arm/cortex-m/: stk_arch_arm-cortex-m.cpp
    ./deps/stk/include/: stk.h stk_arch.h stk_common.h stk_defs.h stk_helper.h stk_linked_list.h
    ./deps/stk/include/time/: stk_time.h stk_time_timer.h stk_time_util.h
    ./deps/stk/include/strategy/: stk_strategy_edf.h stk_strategy_fpriority.h stk_strategy_monotonic.h stk_strategy_rrobin.h stk_strategy_swrrobin.h
    ./deps/stk/include/sync/: stk_sync.h stk_sync_cs.h stk_sync_cv.h stk_sync_event.h stk_sync_eventflags.h stk_sync_msgqueue.h stk_sync_mutex.h stk_sync_pipe.h stk_sync_rwmutex.h stk_sync_semaphore.h stk_sync_spinlock.h
    ./deps/stk/include/memory/: stk_memory.h stk_memory_allocator.h stk_memory_blockpool.h
    ./deps/stk/include/arch/: stk_arch_common.h
    ./deps/stk/include/arch/arm/cortex-m/: stk_arch_arm-cortex-m.h
  group :CubeMX:CubeMX
    ./STM32CubeMX/device/STM32CubeMX/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    ./STM32CubeMX/device/STM32CubeMX/MDK-ARM/: startup_stm32f407xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/device/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Driver
    ./deps/build/example/driver/stm32f4xx/: led.cpp
    ./deps/build/example/driver/: defs.h led.h c_wrapper.cpp
  group Interop/CMSIS/RTOS2
    ./deps/interop/cmsis/rtos2/include/: cmsis_os2.h
    ./deps/interop/cmsis/rtos2/src/: cmsis_os2_stk.cpp
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, Device:CubeMX 1.0.0
