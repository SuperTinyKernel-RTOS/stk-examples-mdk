# Keil uVision project blinky-stm32f407g-disc1.uvprojx, settings and files
target blinky (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blinky-stm32f407g-disc1
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group example
    ./src/: stk_config.h
    ./src/build/example/blinky/: example.cpp example.h
    ./deps/build/example/driver/stm32f4xx/: led.cpp
  group stk
    ./deps/stk/src/arch/arm/cortex-m/: stk_arch_arm-cortex-m.cpp
  group :CubeMX:CubeMX
    ./STM32CubeMX/blinky/STM32CubeMX/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    ./STM32CubeMX/blinky/STM32CubeMX/MDK-ARM/: startup_stm32f407xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/blinky/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
software components: CMSIS:CORE 6.2.0, Device:CubeMX 1.0.0
